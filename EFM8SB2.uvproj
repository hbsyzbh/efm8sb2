# Keil uVision project EFM8SB2.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8SB20F64G-QFN24 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: EFM8SB2
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base
  group Source Group 1
    ./: SILABS_STARTUP.A51 main.c
